options:
  parameters:
    generate_options: qt_gui
    id: gnuilkdeneme
    output_language: python
    title: ilkdeneme
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 144.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.024e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class activity_reporter(gr.sync_block):
          def __init__(self, threshold=1.0):
              gr.sync_block.__init__(
                  self,
                  name="activity_reporter",
                  in_sig=[(np.complex64, 1)],  # Karmaşık 32-bit kayan nokta türü için güncellenmiş imza
                  out_sig=None
              )
              self.threshold = threshold

          def work(self, input_items, output_items):
              fft_data = input_items[0]
              # Karmaşık veri olduğundan gücü hesaplayarak gerçek bir değere dönüştürüyoruz.
              power = np.abs(fft_data)**2
              max_power = np.amax(power)

              if max_power > self.threshold:
                  current_time = np.datetime64('now')
                  print(f"Activity detected at {current_time} with power {max_power}")

              return len(input_items[0])
    threshold: '0.0001'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', epy_block_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
